# Keil uVision project STM32_READ_TXT.uvprojx, settings and files
target READ_TXT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_READ_TXT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\FATFS\src;.\SYSTEM\Usart;.\SYSTEM\Delay;.\SYSTEM\Timer;.\SYSTEM\Led;.\SYSTEM\Beep;.\SYSTEM\Rtc;.\SYSTEM\Sys;.\SYSTEM\Exti;.\SYSTEM\Lcd_Nt35310;.\SYSTEM\Sdio;.\SYSTEM\Spi;.\SYSTEM\W25qXX;.\SYSTEM\Touch;.\TEXT;.\READ_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/Usart/: usart.c
    ./SYSTEM/Delay/: delay.c
    ./SYSTEM/Timer/: timer.c
    ./SYSTEM/Led/: led.c
    ./SYSTEM/Beep/: beep.c
    ./SYSTEM/Rtc/: rtc.c
    ./SYSTEM/Sys/: sys.c
    ./SYSTEM/Exti/: exti.c
    ./SYSTEM/Lcd_Nt35310/: lcd.c
    ./SYSTEM/W25qXX/: w25qxx.c
    ./SYSTEM/Sdio/: sdio_sdcard.c
    ./SYSTEM/Spi/: spi.c
    ./SYSTEM/Touch/: gt9147.c ctiic.c
  group FATFS
    ./FATFS/src/: diskio.c ff.c ffconf.h
    ./FATFS/src/option/: cc936.c
  group TEXT
    ./TEXT/: fontupd.c text.c
  group READ_APP
    ./READ_APP/: app_control.c app_gui.c app_work.c app_main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
